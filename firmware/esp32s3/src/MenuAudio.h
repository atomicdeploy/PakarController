#pragma once
#include <Protocol.h>
#include <AudioCues.h>

namespace PakarS3 {
// Menu sound is generated by AVR, never a new S3 buzzer pin. The caller owns
// its single sequence allocator and calls observe for actual AVR frames only.
class MenuAudio {
 public:
  void observe(const BoardCore::Protocol::Frame &frame, uint32_t now) {
    tick(now);
    using namespace BoardCore::Protocol;
    if (frame.opcode == kHelloResponse && frame.payloadLength >= 13 &&
        frame.payload[0] == 0 && frame.payload[1] == kRoleAvr) {
      advertised_ = (frame.payload[2] | (uint16_t(frame.payload[3]) << 8)) & kCapBuzzer;
      cues_ = frame.payload[12];
      helloAt_ = now;
      known_ = true;
    }
    if (pending_ && frame.sequence == sequence_ && frame.payloadLength == 2 &&
        frame.payload[0] == kAudioCue &&
        (frame.opcode == kAck || frame.opcode == kErrorResponse)) {
      accepted_ = frame.opcode == kAck && frame.payload[1] == kNoError;
      pending_ = false;
    }
  }
  void disconnected() { known_ = pending_ = accepted_ = false; }
  void tick(uint32_t now) {
    if (pending_ && uint32_t(now - sentAt_) > 250) {
      pending_ = false; accepted_ = false;
    }
  }
  bool pending() const { return pending_; }
  bool accepted() const { return accepted_; }
  template <class Sender>
  bool navigate(Sender &sender, uint8_t sequence, bool forward, uint32_t now) {
    tick(now);
    using namespace BoardCore::Protocol;
    if (!enabled_ || !known_ || uint32_t(now - helloAt_) > 3000) return false;
    if (pending_ && uint32_t(now - sentAt_) <= 250) return false;
    pending_ = false;
    const uint8_t cue = forward ? kCueIncrease : kCueDecrease;
    if (BoardCore::AudioCues::supportedCount(true, advertised_, cues_) <= cue) return false;
    if (sent_ && uint32_t(now - sentAt_) < 80) return false;
    accepted_ = false;
    if (!sender.send(kAudioCue, sequence, &cue, 1)) return false;
    sent_ = pending_ = true; sequence_ = sequence; sentAt_ = now;
    return true; // queued only; accepted() requires the correlated AVR ACK.
  }
  void setEnabled(bool enabled) { enabled_ = enabled; }
 private:
  bool enabled_ = true, known_ = false, advertised_ = false;
  bool pending_ = false, accepted_ = false, sent_ = false;
  uint8_t cues_ = 0, sequence_ = 0;
  uint32_t helloAt_ = 0, sentAt_ = 0;
};
} // namespace PakarS3
